# Repository nicksan222/chess (continued)

## KiCad design hardware/pcb/generated/chess-board.kicad_pcb (continued)

Schematic: components-14.kicad_sch, Components 14: HS17 to HS27

Parts:
HS2, HS17, HS18, HS19, HS20, HS21, HS22, HS23, HS24, HS25, HS26, HS27: DRV5032FCDBZR; HALL_SENSOR

Connections:
+3V3: HS2.1 (SUPPLY), HS17.1 (SUPPLY), HS18.1 (SUPPLY), HS19.1 (SUPPLY), HS20.1 (SUPPLY), HS21.1 (SUPPLY), HS22.1 (SUPPLY), HS23.1 (SUPPLY), HS24.1 (SUPPLY), HS25.1 (SUPPLY), HS26.1 (SUPPLY), HS27.1 (SUPPLY); also elsewhere on the board
GND: HS2.3 (GROUND), HS17.3 (GROUND), HS18.3 (GROUND), HS19.3 (GROUND), HS20.3 (GROUND), HS21.3 (GROUND), HS22.3 (GROUND), HS23.3 (GROUND), HS24.3 (GROUND), HS25.3 (GROUND), HS26.3 (GROUND), HS27.3 (GROUND); also elsewhere on the board
SQ_B1: HS2.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_E1: HS17.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_E2: HS21.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_E3: HS25.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_F1: HS18.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_F2: HS22.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_F3: HS26.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_G1: HS19.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_G2: HS23.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_G3: HS27.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_H1: HS20.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_H2: HS24.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board

Schematic: components-15.kicad_sch, Components 15: HS28 to HS38

Parts:
HS3, HS28, HS29, HS30, HS31, HS32, HS33, HS34, HS35, HS36, HS37, HS38: DRV5032FCDBZR; HALL_SENSOR

Connections:
+3V3: HS3.1 (SUPPLY), HS28.1 (SUPPLY), HS29.1 (SUPPLY), HS30.1 (SUPPLY), HS31.1 (SUPPLY), HS32.1 (SUPPLY), HS33.1 (SUPPLY), HS34.1 (SUPPLY), HS35.1 (SUPPLY), HS36.1 (SUPPLY), HS37.1 (SUPPLY), HS38.1 (SUPPLY); also elsewhere on the board
GND: HS3.3 (GROUND), HS28.3 (GROUND), HS29.3 (GROUND), HS30.3 (GROUND), HS31.3 (GROUND), HS32.3 (GROUND), HS33.3 (GROUND), HS34.3 (GROUND), HS35.3 (GROUND), HS36.3 (GROUND), HS37.3 (GROUND), HS38.3 (GROUND); also elsewhere on the board
SQ_A5: HS33.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_A6: HS37.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_B5: HS34.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_B6: HS38.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_C1: HS3.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_C5: HS35.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_D5: HS36.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_E4: HS29.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_F4: HS30.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_G4: HS31.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_H3: HS28.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_H4: HS32.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board

Schematic: components-16.kicad_sch, Components 16: HS39 to HS49

Parts:
HS4, HS39, HS40, HS41, HS42, HS43, HS44, HS45, HS46, HS47, HS48, HS49: DRV5032FCDBZR; HALL_SENSOR

Connections:
+3V3: HS4.1 (SUPPLY), HS39.1 (SUPPLY), HS40.1 (SUPPLY), HS41.1 (SUPPLY), HS42.1 (SUPPLY), HS43.1 (SUPPLY), HS44.1 (SUPPLY), HS45.1 (SUPPLY), HS46.1 (SUPPLY), HS47.1 (SUPPLY), HS48.1 (SUPPLY), HS49.1 (SUPPLY); also elsewhere on the board
GND: HS4.3 (GROUND), HS39.3 (GROUND), HS40.3 (GROUND), HS41.3 (GROUND), HS42.3 (GROUND), HS43.3 (GROUND), HS44.3 (GROUND), HS45.3 (GROUND), HS46.3 (GROUND), HS47.3 (GROUND), HS48.3 (GROUND), HS49.3 (GROUND); also elsewhere on the board
SQ_A7: HS41.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_A8: HS45.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_B7: HS42.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_B8: HS46.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_C6: HS39.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_C7: HS43.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_C8: HS47.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_D1: HS4.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_D6: HS40.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_D7: HS44.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_D8: HS48.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_E5: HS49.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board

Schematic: components-17.kicad_sch, Components 17: HS5 to HS6

Parts:
HS5, HS6, HS50, HS51, HS52, HS53, HS54, HS55, HS56, HS57, HS58, HS59: DRV5032FCDBZR; HALL_SENSOR

Connections:
+3V3: HS5.1 (SUPPLY), HS6.1 (SUPPLY), HS50.1 (SUPPLY), HS51.1 (SUPPLY), HS52.1 (SUPPLY), HS53.1 (SUPPLY), HS54.1 (SUPPLY), HS55.1 (SUPPLY), HS56.1 (SUPPLY), HS57.1 (SUPPLY), HS58.1 (SUPPLY), HS59.1 (SUPPLY); also elsewhere on the board
GND: HS5.3 (GROUND), HS6.3 (GROUND), HS50.3 (GROUND), HS51.3 (GROUND), HS52.3 (GROUND), HS53.3 (GROUND), HS54.3 (GROUND), HS55.3 (GROUND), HS56.3 (GROUND), HS57.3 (GROUND), HS58.3 (GROUND), HS59.3 (GROUND); also elsewhere on the board
SQ_A2: HS5.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_B2: HS6.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_E6: HS53.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_E7: HS57.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_F5: HS50.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_F6: HS54.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_F7: HS58.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_G5: HS51.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_G6: HS55.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_G7: HS59.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_H5: HS52.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_H6: HS56.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board

Schematic: components-18.kicad_sch, Components 18: HS60 to Q1

Parts:
HS7, HS8, HS9, HS60, HS61, HS62, HS63, HS64: DRV5032FCDBZR; HALL_SENSOR
J1: PPPC202LFBN-RC; PI_ZERO_HEADER
J2: SM04B-SRSS-TB; OLED_HEADER
J4: B4PS-VH; POWER_HEADER
Q1: Si4403DDY-T1-GE3; LED_SWITCH

Connections:
+3V3: HS7.1 (SUPPLY), HS8.1 (SUPPLY), HS9.1 (SUPPLY), HS60.1 (SUPPLY), HS61.1 (SUPPLY), HS62.1 (SUPPLY), HS63.1 (SUPPLY), HS64.1 (SUPPLY), J1.1 (THREE_VOLTS_THREE), J1.17 (THREE_VOLTS_THREE_ALT), J2.2 (THREE_VOLTS_THREE); also elsewhere on the board
+5V: J1.2 (FIVE_VOLTS), J1.4 (FIVE_VOLTS_ALT), Q1.1 (SOURCE_1), Q1.2 (SOURCE_2), Q1.3 (SOURCE_3); also elsewhere on the board
BTN_DOWN: J1.31 (BUTTON_DOWN_GPIO6); also elsewhere on the board
BTN_F1: J1.38 (BUTTON_F1_GPIO20); also elsewhere on the board
BTN_F2: J1.40 (BUTTON_F2_GPIO21); also elsewhere on the board
BTN_F3: J1.15 (BUTTON_F3_GPIO22); also elsewhere on the board
BTN_F4: J1.16 (BUTTON_F4_GPIO23); also elsewhere on the board
BTN_F5: J1.18 (BUTTON_F5_GPIO24); also elsewhere on the board
BTN_LEFT: J1.32 (BUTTON_LEFT_GPIO12); also elsewhere on the board
BTN_OK: J1.36 (BUTTON_OK_GPIO16); also elsewhere on the board
BTN_PASS: J1.35 (BUTTON_PASS_GPIO19); also elsewhere on the board
BTN_RESET: J1.11 (BUTTON_RESET_GPIO17); also elsewhere on the board
BTN_RIGHT: J1.33 (BUTTON_RIGHT_GPIO13); also elsewhere on the board
BTN_UP: J1.29 (BUTTON_UP_GPIO5); also elsewhere on the board
DC_FUSED: J4.3 (FUSED_TO_SWITCH); also elsewhere on the board
DC_IN: J4.1 (DC_INPUT); also elsewhere on the board
GND: HS7.3 (GROUND), HS8.3 (GROUND), HS9.3 (GROUND), HS60.3 (GROUND), HS61.3 (GROUND), HS62.3 (GROUND), HS63.3 (GROUND), HS64.3 (GROUND), J1.6 (GROUND_6), J1.9 (GROUND_9), J1.14 (GROUND_14), J1.20 (GROUND_20), J1.25 (GROUND_25), J1.30 (GROUND_30), J1.34 (GROUND_34), J1.39 (GROUND_39), J2.1 (GROUND), J2.5 (MOUNTING_TAB_A), J2.6 (MOUNTING_TAB_B), J4.2 (GROUND); also elsewhere on the board
I2C_SCL: J1.5 (I2C_SCL), J2.3 (I2C_CLOCK); also elsewhere on the board
I2C_SDA: J1.3 (I2C_SDA), J2.4 (I2C_DATA); also elsewhere on the board
LED_5V: Q1.5 (DRAIN_5), Q1.6 (DRAIN_6), Q1.7 (DRAIN_7), Q1.8 (DRAIN_8); also elsewhere on the board
LED_EN: J1.37 (LED_EN_GPIO26); also elsewhere on the board
LED_SW_GATE: Q1.4 (GATE); also elsewhere on the board
RUN: J4.4 (RUN); also elsewhere on the board
SPI_CLK_3V3: J1.23 (SPI_CLOCK_GPIO11); also elsewhere on the board
SPI_DATA_3V3: J1.19 (SPI_DATA_GPIO10); also elsewhere on the board
SQ_A3: HS9.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_C2: HS7.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_D2: HS8.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_E8: HS61.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_F8: HS62.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_G8: HS63.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_H7: HS60.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board
SQ_H8: HS64.2 (ACTIVE_LOW_OUTPUT); also elsewhere on the board

Schematic: components-19.kicad_sch, Components 19: Q2 to R4

Parts:
Q2: BSS138LT1G; LED_SWITCH_DRIVER
R3: RC0603FR-071K65L; RES_1K65
R4: RT0603BRD07604KL; RES_604K_PRECISION
R10, R11, R12: RC0603FR-0756RL; RES_56
R13: RC0603FR-071KL; RES_1K
R14, R16: RC0603FR-07100KL; RES_100K
R15, R17, R18: RC0603FR-0710KL; RES_10K

Connections:
+5V: R15.2 (TERMINAL_B); also elsewhere on the board
DC_FUSED: R4.2 (TERMINAL_B); also elsewhere on the board
EFUSE_ILM: R3.1 (TERMINAL_A); also elsewhere on the board
EFUSE_OVLO: R4.1 (TERMINAL_A); also elsewhere on the board
GND: Q2.2 (SOURCE), R3.2 (TERMINAL_B), R14.2 (TERMINAL_B), R17.2 (TERMINAL_B), R18.2 (TERMINAL_B); also elsewhere on the board
LED_CLK_5V: R18.1 (TERMINAL_A); also elsewhere on the board
LED_DATA_5V: R17.1 (TERMINAL_A); also elsewhere on the board
LED_DATA_A2_TO_A3: R10.1 (TERMINAL_A); also elsewhere on the board
LED_DATA_A2_TO_A3_SRC: R10.2 (TERMINAL_B); also elsewhere on the board
LED_DATA_A4_TO_A5: R11.1 (TERMINAL_A); also elsewhere on the board
LED_DATA_A4_TO_A5_SRC: R11.2 (TERMINAL_B); also elsewhere on the board
LED_DATA_A6_TO_A7: R12.1 (TERMINAL_A); also elsewhere on the board
LED_DATA_A6_TO_A7_SRC: R12.2 (TERMINAL_B); also elsewhere on the board
LED_EN: R13.1 (TERMINAL_A); also elsewhere on the board
LED_EN_GATE: Q2.1 (GATE), R13.2 (TERMINAL_B), R14.1 (TERMINAL_A)
LED_EN_N: Q2.3 (DRAIN), R15.1 (TERMINAL_A), R16.1 (TERMINAL_A); also elsewhere on the board
LED_SW_GATE: R16.2 (TERMINAL_B); also elsewhere on the board

Schematic: components-20.kicad_sch, Components 20: R5 to SW4

Parts:
R5: RT0603BRD07169KL; RES_169K_PRECISION
R6: RT0603BRD07604KL; RES_604K_PRECISION
R7: RC0603FR-07261KL; RES_261K
R8: RC0603FR-071KL; RES_1K
R9: RC0603FR-0756RL; RES_56
SW1, SW2, SW3, SW4, SW10, SW11, SW12: TL1105CF100Q; BUTTON

Connections:
BTN_DOWN: SW2.1 (SIGNAL), SW2.1b (SIGNAL); also elsewhere on the board
BTN_F3: SW10.1 (SIGNAL), SW10.1b (SIGNAL); also elsewhere on the board
BTN_F4: SW11.1 (SIGNAL), SW11.1b (SIGNAL); also elsewhere on the board
BTN_F5: SW12.1 (SIGNAL), SW12.1b (SIGNAL); also elsewhere on the board
BTN_LEFT: SW3.1 (SIGNAL), SW3.1b (SIGNAL); also elsewhere on the board
BTN_RIGHT: SW4.1 (SIGNAL), SW4.1b (SIGNAL); also elsewhere on the board
BTN_UP: SW1.1 (SIGNAL), SW1.1b (SIGNAL); also elsewhere on the board
EFUSE_EN: R6.2 (TERMINAL_B), R7.1 (TERMINAL_A); also elsewhere on the board
EFUSE_OVLO: R5.1 (TERMINAL_A); also elsewhere on the board
GND: R5.2 (TERMINAL_B), R7.2 (TERMINAL_B), R8.2 (TERMINAL_B), SW1.2 (GROUND), SW1.2b (GROUND), SW2.2 (GROUND), SW2.2b (GROUND), SW3.2 (GROUND), SW3.2b (GROUND), SW4.2 (GROUND), SW4.2b (GROUND), SW10.2 (GROUND), SW10.2b (GROUND), SW11.2 (GROUND), SW11.2b (GROUND), SW12.2 (GROUND), SW12.2b (GROUND); also elsewhere on the board
LED_DATA_5V: R9.1 (TERMINAL_A); also elsewhere on the board
LED_DATA_BUF: R9.2 (TERMINAL_B); also elsewhere on the board
RUN: R6.1 (TERMINAL_A), R8.1 (TERMINAL_A); also elsewhere on the board

Schematic: components-21.kicad_sch, Components 21: SW5 to TP7

Parts:
SW5, SW6, SW7, SW8, SW9: TL1105CF100Q; BUTTON
TP1, TP2, TP3, TP4, TP5, TP6, TP7: S1751-46R; TEST_POINT

Connections:
+3V3: TP5.1; also elsewhere on the board
+5V: TP1.1; also elsewhere on the board
BTN_F1: SW8.1 (SIGNAL), SW8.1b (SIGNAL); also elsewhere on the board
BTN_F2: SW9.1 (SIGNAL), SW9.1b (SIGNAL); also elsewhere on the board
BTN_OK: SW5.1 (SIGNAL), SW5.1b (SIGNAL); also elsewhere on the board
BTN_PASS: SW7.1 (SIGNAL), SW7.1b (SIGNAL); also elsewhere on the board
BTN_RESET: SW6.1 (SIGNAL), SW6.1b (SIGNAL); also elsewhere on the board
GND: SW5.2 (GROUND), SW5.2b (GROUND), SW6.2 (GROUND), SW6.2b (GROUND), SW7.2 (GROUND), SW7.2b (GROUND), SW8.2 (GROUND), SW8.2b (GROUND), SW9.2 (GROUND), SW9.2b (GROUND), TP2.1; also elsewhere on the board
I2C_SCL: TP6.1; also elsewhere on the board
I2C_SDA: TP7.1; also elsewhere on the board
LED_CLK_5V: TP4.1; also elsewhere on the board
LED_DATA_5V: TP3.1; also elsewhere on the board

Schematic: components-22.kicad_sch, Components 22: U1 to U2

Parts:
U1, U2: TCA9554DWR; TCA9554
U10, U11, U12, U13, U14, U15, U16, U17, U18, U19: SK9822-A; SK9822

Connections:
+3V3: U1.16 (SUPPLY), U2.1 (ADDRESS_0), U2.16 (SUPPLY); also elsewhere on the board
GND: U1.1 (ADDRESS_0), U1.2 (ADDRESS_1), U1.3 (ADDRESS_2), U1.8 (GROUND), U2.2 (ADDRESS_1), U2.3 (ADDRESS_2), U2.8 (GROUND), U10.3 (GROUND), U11.3 (GROUND), U12.3 (GROUND), U13.3 (GROUND), U14.3 (GROUND), U15.3 (GROUND), U16.3 (GROUND), U17.3 (GROUND), U18.3 (GROUND), U19.3 (GROUND); also elsewhere on the board
I2C_SCL: U1.14 (I2C_CLOCK), U2.14 (I2C_CLOCK); also elsewhere on the board
I2C_SDA: U1.15 (I2C_DATA), U2.15 (I2C_DATA); also elsewhere on the board
LED_5V: U10.4 (FIVE_VOLTS), U11.4 (FIVE_VOLTS), U12.4 (FIVE_VOLTS), U13.4 (FIVE_VOLTS), U14.4 (FIVE_VOLTS), U15.4 (FIVE_VOLTS), U16.4 (FIVE_VOLTS), U17.4 (FIVE_VOLTS), U18.4 (FIVE_VOLTS), U19.4 (FIVE_VOLTS); also elsewhere on the board
LED_CLOCK_C2_TO_B2: U19.5 (CLOCK_OUT); also elsewhere on the board
LED_CLOCK_D1_TO_E1: U10.2 (CLOCK_IN); also elsewhere on the board
LED_CLOCK_D2_TO_C2: U18.5 (CLOCK_OUT), U19.2 (CLOCK_IN)
LED_CLOCK_E1_TO_F1: U10.5 (CLOCK_OUT), U11.2 (CLOCK_IN)
LED_CLOCK_E2_TO_D2: U17.5 (CLOCK_OUT), U18.2 (CLOCK_IN)
LED_CLOCK_F1_TO_G1: U11.5 (CLOCK_OUT), U12.2 (CLOCK_IN)
LED_CLOCK_F2_TO_E2: U16.5 (CLOCK_OUT), U17.2 (CLOCK_IN)
LED_CLOCK_G1_TO_H1: U12.5 (CLOCK_OUT), U13.2 (CLOCK_IN)
LED_CLOCK_G2_TO_F2: U15.5 (CLOCK_OUT), U16.2 (CLOCK_IN)
LED_CLOCK_H1_TO_H2: U13.5 (CLOCK_OUT), U14.2 (CLOCK_IN)
LED_CLOCK_H2_TO_G2: U14.5 (CLOCK_OUT), U15.2 (CLOCK_IN)
LED_DATA_C2_TO_B2: U19.6 (DATA_OUT); also elsewhere on the board
LED_DATA_D1_TO_E1: U10.1 (DATA_IN); also elsewhere on the board
LED_DATA_D2_TO_C2: U18.6 (DATA_OUT), U19.1 (DATA_IN)
LED_DATA_E1_TO_F1: U10.6 (DATA_OUT), U11.1 (DATA_IN)
LED_DATA_E2_TO_D2: U17.6 (DATA_OUT), U18.1 (DATA_IN)
LED_DATA_F1_TO_G1: U11.6 (DATA_OUT), U12.1 (DATA_IN)
LED_DATA_F2_TO_E2: U16.6 (DATA_OUT), U17.1 (DATA_IN)
LED_DATA_G1_TO_H1: U12.6 (DATA_OUT), U13.1 (DATA_IN)
LED_DATA_G2_TO_F2: U15.6 (DATA_OUT), U16.1 (DATA_IN)
LED_DATA_H1_TO_H2: U13.6 (DATA_OUT), U14.1 (DATA_IN)
LED_DATA_H2_TO_G2: U14.6 (DATA_OUT), U15.1 (DATA_IN)
SQ_A1: U1.4 (P0); also elsewhere on the board
SQ_A2: U1.6 (P2); also elsewhere on the board
SQ_B1: U1.5 (P1); also elsewhere on the board
SQ_B2: U1.7 (P3); also elsewhere on the board
SQ_C1: U1.9 (P4); also elsewhere on the board
SQ_C2: U1.11 (P6); also elsewhere on the board
SQ_D1: U1.10 (P5); also elsewhere on the board
SQ_D2: U1.12 (P7); also elsewhere on the board
SQ_E1: U2.4 (P0); also elsewhere on the board
SQ_E2: U2.6 (P2); also elsewhere on the board
SQ_F1: U2.5 (P1); also elsewhere on the board
SQ_F2: U2.7 (P3); also elsewhere on the board
SQ_G1: U2.9 (P4); also elsewhere on the board
SQ_G2: U2.11 (P6); also elsewhere on the board
SQ_H1: U2.10 (P5); also elsewhere on the board
SQ_H2: U2.12 (P7); also elsewhere on the board

Schematic: components-23.kicad_sch, Components 23: U20 to U30

Parts:
U3: TCA9554DWR; TCA9554
U20, U21, U22, U23, U24, U25, U26, U27, U28, U29, U30: SK9822-A; SK9822

Connections:
+3V3: U3.2 (ADDRESS_1), U3.16 (SUPPLY); also elsewhere on the board
GND: U3.1 (ADDRESS_0), U3.3 (ADDRESS_2), U3.8 (GROUND), U20.3 (GROUND), U21.3 (GROUND), U22.3 (GROUND), U23.3 (GROUND), U24.3 (GROUND), U25.3 (GROUND), U26.3 (GROUND), U27.3 (GROUND), U28.3 (GROUND), U29.3 (GROUND), U30.3 (GROUND); also elsewhere on the board
I2C_SCL: U3.14 (I2C_CLOCK); also elsewhere on the board
I2C_SDA: U3.15 (I2C_DATA); also elsewhere on the board
LED_5V: U20.4 (FIVE_VOLTS), U21.4 (FIVE_VOLTS), U22.4 (FIVE_VOLTS), U23.4 (FIVE_VOLTS), U24.4 (FIVE_VOLTS), U25.4 (FIVE_VOLTS), U26.4 (FIVE_VOLTS), U27.4 (FIVE_VOLTS), U28.4 (FIVE_VOLTS), U29.4 (FIVE_VOLTS), U30.4 (FIVE_VOLTS); also elsewhere on the board
LED_CLOCK_A2_TO_A3: U21.5 (CLOCK_OUT), U22.2 (CLOCK_IN)
LED_CLOCK_A3_TO_B3: U22.5 (CLOCK_OUT), U23.2 (CLOCK_IN)
LED_CLOCK_B2_TO_A2: U20.5 (CLOCK_OUT), U21.2 (CLOCK_IN)
LED_CLOCK_B3_TO_C3: U23.5 (CLOCK_OUT), U24.2 (CLOCK_IN)
LED_CLOCK_C2_TO_B2: U20.2 (CLOCK_IN); also elsewhere on the board
LED_CLOCK_C3_TO_D3: U24.5 (CLOCK_OUT), U25.2 (CLOCK_IN)
LED_CLOCK_D3_TO_E3: U25.5 (CLOCK_OUT), U26.2 (CLOCK_IN)
LED_CLOCK_E3_TO_F3: U26.5 (CLOCK_OUT), U27.2 (CLOCK_IN)
LED_CLOCK_F3_TO_G3: U27.5 (CLOCK_OUT), U28.2 (CLOCK_IN)
LED_CLOCK_G3_TO_H3: U28.5 (CLOCK_OUT), U29.2 (CLOCK_IN)
LED_CLOCK_H3_TO_H4: U29.5 (CLOCK_OUT), U30.2 (CLOCK_IN)
LED_CLOCK_H4_TO_G4: U30.5 (CLOCK_OUT); also elsewhere on the board
LED_DATA_A2_TO_A3: U22.1 (DATA_IN); also elsewhere on the board
LED_DATA_A2_TO_A3_SRC: U21.6 (DATA_OUT); also elsewhere on the board
LED_DATA_A3_TO_B3: U22.6 (DATA_OUT), U23.1 (DATA_IN)
LED_DATA_B2_TO_A2: U20.6 (DATA_OUT), U21.1 (DATA_IN)
LED_DATA_B3_TO_C3: U23.6 (DATA_OUT), U24.1 (DATA_IN)
LED_DATA_C2_TO_B2: U20.1 (DATA_IN); also elsewhere on the board
LED_DATA_C3_TO_D3: U24.6 (DATA_OUT), U25.1 (DATA_IN)
LED_DATA_D3_TO_E3: U25.6 (DATA_OUT), U26.1 (DATA_IN)
LED_DATA_E3_TO_F3: U26.6 (DATA_OUT), U27.1 (DATA_IN)
LED_DATA_F3_TO_G3: U27.6 (DATA_OUT), U28.1 (DATA_IN)
LED_DATA_G3_TO_H3: U28.6 (DATA_OUT), U29.1 (DATA_IN)
LED_DATA_H3_TO_H4: U29.6 (DATA_OUT), U30.1 (DATA_IN)
LED_DATA_H4_TO_G4: U30.6 (DATA_OUT); also elsewhere on the board
SQ_A3: U3.4 (P0); also elsewhere on the board
SQ_A4: U3.6 (P2); also elsewhere on the board
SQ_B3: U3.5 (P1); also elsewhere on the board
SQ_B4: U3.7 (P3); also elsewhere on the board
SQ_C3: U3.9 (P4); also elsewhere on the board
SQ_C4: U3.11 (P6); also elsewhere on the board
SQ_D3: U3.10 (P5); also elsewhere on the board
SQ_D4: U3.12 (P7); also elsewhere on the board

Schematic: components-24.kicad_sch, Components 24: U31 to U41

Parts:
U4: TCA9554DWR; TCA9554
U31, U32, U33, U34, U35, U36, U37, U38, U39, U40, U41: SK9822-A; SK9822

Connections:
+3V3: U4.1 (ADDRESS_0), U4.2 (ADDRESS_1), U4.16 (SUPPLY); also elsewhere on the board
GND: U4.3 (ADDRESS_2), U4.8 (GROUND), U31.3 (GROUND), U32.3 (GROUND), U33.3 (GROUND), U34.3 (GROUND), U35.3 (GROUND), U36.3 (GROUND), U37.3 (GROUND), U38.3 (GROUND), U39.3 (GROUND), U40.3 (GROUND), U41.3 (GROUND); also elsewhere on the board
I2C_SCL: U4.14 (I2C_CLOCK); also elsewhere on the board
I2C_SDA: U4.15 (I2C_DATA); also elsewhere on the board
LED_5V: U31.4 (FIVE_VOLTS), U32.4 (FIVE_VOLTS), U33.4 (FIVE_VOLTS), U34.4 (FIVE_VOLTS), U35.4 (FIVE_VOLTS), U36.4 (FIVE_VOLTS), U37.4 (FIVE_VOLTS), U38.4 (FIVE_VOLTS), U39.4 (FIVE_VOLTS), U40.4 (FIVE_VOLTS), U41.4 (FIVE_VOLTS); also elsewhere on the board
LED_CLOCK_A4_TO_A5: U37.5 (CLOCK_OUT), U38.2 (CLOCK_IN)
LED_CLOCK_A5_TO_B5: U38.5 (CLOCK_OUT), U39.2 (CLOCK_IN)
LED_CLOCK_B4_TO_A4: U36.5 (CLOCK_OUT), U37.2 (CLOCK_IN)
LED_CLOCK_B5_TO_C5: U39.5 (CLOCK_OUT), U40.2 (CLOCK_IN)
LED_CLOCK_C4_TO_B4: U35.5 (CLOCK_OUT), U36.2 (CLOCK_IN)
LED_CLOCK_C5_TO_D5: U40.5 (CLOCK_OUT), U41.2 (CLOCK_IN)
LED_CLOCK_D4_TO_C4: U34.5 (CLOCK_OUT), U35.2 (CLOCK_IN)
LED_CLOCK_D5_TO_E5: U41.5 (CLOCK_OUT); also elsewhere on the board
LED_CLOCK_E4_TO_D4: U33.5 (CLOCK_OUT), U34.2 (CLOCK_IN)
LED_CLOCK_F4_TO_E4: U32.5 (CLOCK_OUT), U33.2 (CLOCK_IN)
LED_CLOCK_G4_TO_F4: U31.5 (CLOCK_OUT), U32.2 (CLOCK_IN)
LED_CLOCK_H4_TO_G4: U31.2 (CLOCK_IN); also elsewhere on the board
LED_DATA_A4_TO_A5: U38.1 (DATA_IN); also elsewhere on the board
LED_DATA_A4_TO_A5_SRC: U37.6 (DATA_OUT); also elsewhere on the board
LED_DATA_A5_TO_B5: U38.6 (DATA_OUT), U39.1 (DATA_IN)
LED_DATA_B4_TO_A4: U36.6 (DATA_OUT), U37.1 (DATA_IN)
LED_DATA_B5_TO_C5: U39.6 (DATA_OUT), U40.1 (DATA_IN)
LED_DATA_C4_TO_B4: U35.6 (DATA_OUT), U36.1 (DATA_IN)
LED_DATA_C5_TO_D5: U40.6 (DATA_OUT), U41.1 (DATA_IN)
LED_DATA_D4_TO_C4: U34.6 (DATA_OUT), U35.1 (DATA_IN)
LED_DATA_D5_TO_E5: U41.6 (DATA_OUT); also elsewhere on the board
LED_DATA_E4_TO_D4: U33.6 (DATA_OUT), U34.1 (DATA_IN)
LED_DATA_F4_TO_E4: U32.6 (DATA_OUT), U33.1 (DATA_IN)
LED_DATA_G4_TO_F4: U31.6 (DATA_OUT), U32.1 (DATA_IN)
LED_DATA_H4_TO_G4: U31.1 (DATA_IN); also elsewhere on the board
SQ_E3: U4.4 (P0); also elsewhere on the board
SQ_E4: U4.6 (P2); also elsewhere on the board
SQ_F3: U4.5 (P1); also elsewhere on the board
SQ_F4: U4.7 (P3); also elsewhere on the board
SQ_G3: U4.9 (P4); also elsewhere on the board
SQ_G4: U4.11 (P6); also elsewhere on the board
SQ_H3: U4.10 (P5); also elsewhere on the board
SQ_H4: U4.12 (P7); also elsewhere on the board

Schematic: components-25.kicad_sch, Components 25: U42 to U52

Parts:
U5: SN74AHCT125DR; AHCT125
U42, U43, U44, U45, U46, U47, U48, U49, U50, U51, U52: SK9822-A; SK9822

Connections:
+5V: U5.10 (BUFFER_3_OUTPUT_ENABLE), U5.13 (BUFFER_4_OUTPUT_ENABLE), U5.14 (SUPPLY); also elsewhere on the board
GND: U5.7 (GROUND), U5.9 (BUFFER_3_INPUT), U5.12 (BUFFER_4_INPUT), U42.3 (GROUND), U43.3 (GROUND), U44.3 (GROUND), U45.3 (GROUND), U46.3 (GROUND), U47.3 (GROUND), U48.3 (GROUND), U49.3 (GROUND), U50.3 (GROUND), U51.3 (GROUND), U52.3 (GROUND); also elsewhere on the board
LED_5V: U42.4 (FIVE_VOLTS), U43.4 (FIVE_VOLTS), U44.4 (FIVE_VOLTS), U45.4 (FIVE_VOLTS), U46.4 (FIVE_VOLTS), U47.4 (FIVE_VOLTS), U48.4 (FIVE_VOLTS), U49.4 (FIVE_VOLTS), U50.4 (FIVE_VOLTS), U51.4 (FIVE_VOLTS), U52.4 (FIVE_VOLTS); also elsewhere on the board
LED_CLK_5V: U5.6 (BUFFER_2_OUTPUT); also elsewhere on the board
LED_CLOCK_B6_TO_A6: U52.5 (CLOCK_OUT); also elsewhere on the board
LED_CLOCK_C6_TO_B6: U51.5 (CLOCK_OUT), U52.2 (CLOCK_IN)
LED_CLOCK_D5_TO_E5: U42.2 (CLOCK_IN); also elsewhere on the board
LED_CLOCK_D6_TO_C6: U50.5 (CLOCK_OUT), U51.2 (CLOCK_IN)
LED_CLOCK_E5_TO_F5: U42.5 (CLOCK_OUT), U43.2 (CLOCK_IN)
LED_CLOCK_E6_TO_D6: U49.5 (CLOCK_OUT), U50.2 (CLOCK_IN)
LED_CLOCK_F5_TO_G5: U43.5 (CLOCK_OUT), U44.2 (CLOCK_IN)
LED_CLOCK_F6_TO_E6: U48.5 (CLOCK_OUT), U49.2 (CLOCK_IN)
LED_CLOCK_G5_TO_H5: U44.5 (CLOCK_OUT), U45.2 (CLOCK_IN)
LED_CLOCK_G6_TO_F6: U47.5 (CLOCK_OUT), U48.2 (CLOCK_IN)
LED_CLOCK_H5_TO_H6: U45.5 (CLOCK_OUT), U46.2 (CLOCK_IN)
LED_CLOCK_H6_TO_G6: U46.5 (CLOCK_OUT), U47.2 (CLOCK_IN)
LED_DATA_B6_TO_A6: U52.6 (DATA_OUT); also elsewhere on the board
LED_DATA_BUF: U5.3 (BUFFER_1_OUTPUT); also elsewhere on the board
LED_DATA_C6_TO_B6: U51.6 (DATA_OUT), U52.1 (DATA_IN)
LED_DATA_D5_TO_E5: U42.1 (DATA_IN); also elsewhere on the board
LED_DATA_D6_TO_C6: U50.6 (DATA_OUT), U51.1 (DATA_IN)
LED_DATA_E5_TO_F5: U42.6 (DATA_OUT), U43.1 (DATA_IN)
LED_DATA_E6_TO_D6: U49.6 (DATA_OUT), U50.1 (DATA_IN)
LED_DATA_F5_TO_G5: U43.6 (DATA_OUT), U44.1 (DATA_IN)
LED_DATA_F6_TO_E6: U48.6 (DATA_OUT), U49.1 (DATA_IN)
LED_DATA_G5_TO_H5: U44.6 (DATA_OUT), U45.1 (DATA_IN)
LED_DATA_G6_TO_F6: U47.6 (DATA_OUT), U48.1 (DATA_IN)
LED_DATA_H5_TO_H6: U45.6 (DATA_OUT), U46.1 (DATA_IN)
LED_DATA_H6_TO_G6: U46.6 (DATA_OUT), U47.1 (DATA_IN)
LED_OE_N: U5.1 (BUFFER_1_OUTPUT_ENABLE), U5.4 (BUFFER_2_OUTPUT_ENABLE); also elsewhere on the board
SPI_CLK_3V3: U5.5 (BUFFER_2_INPUT); also elsewhere on the board
SPI_DATA_3V3: U5.2 (BUFFER_1_INPUT); also elsewhere on the board

Schematic: components-26.kicad_sch, Components 26: U53 to U63

Parts:
U6, U53, U54, U55, U56, U57, U58, U59, U60, U61, U62, U63: SK9822-A; SK9822

Connections:
GND: U6.3 (GROUND), U53.3 (GROUND), U54.3 (GROUND), U55.3 (GROUND), U56.3 (GROUND), U57.3 (GROUND), U58.3 (GROUND), U59.3 (GROUND), U60.3 (GROUND), U61.3 (GROUND), U62.3 (GROUND), U63.3 (GROUND); also elsewhere on the board
LED_5V: U6.4 (FIVE_VOLTS), U53.4 (FIVE_VOLTS), U54.4 (FIVE_VOLTS), U55.4 (FIVE_VOLTS), U56.4 (FIVE_VOLTS), U57.4 (FIVE_VOLTS), U58.4 (FIVE_VOLTS), U59.4 (FIVE_VOLTS), U60.4 (FIVE_VOLTS), U61.4 (FIVE_VOLTS), U62.4 (FIVE_VOLTS), U63.4 (FIVE_VOLTS); also elsewhere on the board
LED_CLK_5V: U6.2 (CLOCK_IN); also elsewhere on the board
LED_CLOCK_A1_TO_B1: U6.5 (CLOCK_OUT); also elsewhere on the board
LED_CLOCK_A6_TO_A7: U53.5 (CLOCK_OUT), U54.2 (CLOCK_IN)
LED_CLOCK_A7_TO_B7: U54.5 (CLOCK_OUT), U55.2 (CLOCK_IN)
LED_CLOCK_B6_TO_A6: U53.2 (CLOCK_IN); also elsewhere on the board
LED_CLOCK_B7_TO_C7: U55.5 (CLOCK_OUT), U56.2 (CLOCK_IN)
LED_CLOCK_C7_TO_D7: U56.5 (CLOCK_OUT), U57.2 (CLOCK_IN)
LED_CLOCK_D7_TO_E7: U57.5 (CLOCK_OUT), U58.2 (CLOCK_IN)
LED_CLOCK_E7_TO_F7: U58.5 (CLOCK_OUT), U59.2 (CLOCK_IN)
LED_CLOCK_F7_TO_G7: U59.5 (CLOCK_OUT), U60.2 (CLOCK_IN)
LED_CLOCK_G7_TO_H7: U60.5 (CLOCK_OUT), U61.2 (CLOCK_IN)
LED_CLOCK_G8_TO_F8: U63.5 (CLOCK_OUT); also elsewhere on the board
LED_CLOCK_H7_TO_H8: U61.5 (CLOCK_OUT), U62.2 (CLOCK_IN)
LED_CLOCK_H8_TO_G8: U62.5 (CLOCK_OUT), U63.2 (CLOCK_IN)
LED_DATA_5V: U6.1 (DATA_IN); also elsewhere on the board
LED_DATA_A1_TO_B1: U6.6 (DATA_OUT); also elsewhere on the board
LED_DATA_A6_TO_A7: U54.1 (DATA_IN); also elsewhere on the board
LED_DATA_A6_TO_A7_SRC: U53.6 (DATA_OUT); also elsewhere on the board
LED_DATA_A7_TO_B7: U54.6 (DATA_OUT), U55.1 (DATA_IN)
LED_DATA_B6_TO_A6: U53.1 (DATA_IN); also elsewhere on the board
LED_DATA_B7_TO_C7: U55.6 (DATA_OUT), U56.1 (DATA_IN)
LED_DATA_C7_TO_D7: U56.6 (DATA_OUT), U57.1 (DATA_IN)
LED_DATA_D7_TO_E7: U57.6 (DATA_OUT), U58.1 (DATA_IN)
LED_DATA_E7_TO_F7: U58.6 (DATA_OUT), U59.1 (DATA_IN)
LED_DATA_F7_TO_G7: U59.6 (DATA_OUT), U60.1 (DATA_IN)
LED_DATA_G7_TO_H7: U60.6 (DATA_OUT), U61.1 (DATA_IN)
LED_DATA_G8_TO_F8: U63.6 (DATA_OUT); also elsewhere on the board
LED_DATA_H7_TO_H8: U61.6 (DATA_OUT), U62.1 (DATA_IN)
LED_DATA_H8_TO_G8: U62.6 (DATA_OUT), U63.1 (DATA_IN)

Schematic: components-27.kicad_sch, Components 27: U64 to U74

Parts:
U7, U64, U65, U66, U67, U68, U69: SK9822-A; SK9822
U70, U71, U72, U73: TCA9554DWR; TCA9554
U74: TPS259474ARPWR; EFUSE

Connections:
+3V3: U70.3 (ADDRESS_2), U70.16 (SUPPLY), U71.1 (ADDRESS_0), U71.3 (ADDRESS_2), U71.16 (SUPPLY), U72.2 (ADDRESS_1), U72.3 (ADDRESS_2), U72.16 (SUPPLY), U73.1 (ADDRESS_0), U73.2 (ADDRESS_1), U73.3 (ADDRESS_2), U73.16 (SUPPLY); also elsewhere on the board
+5V: U74.6 (OUTPUT); also elsewhere on the board
DC_FUSED: U74.5 (INPUT); also elsewhere on the board
EFUSE_DVDT: U74.7 (SLEW_RATE); also elsewhere on the board
EFUSE_EN: U74.1 (ENABLE_UVLO); also elsewhere on the board
EFUSE_ILM: U74.9 (CURRENT_LIMIT); also elsewhere on the board
EFUSE_ITIMER: U74.10 (OVERCURRENT_TIMER); also elsewhere on the board
EFUSE_OVLO: U74.2 (OVERVOLTAGE_LOCKOUT), U74.4 (POWER_GOOD_THRESHOLD); also elsewhere on the board
GND: U7.3 (GROUND), U64.3 (GROUND), U65.3 (GROUND), U66.3 (GROUND), U67.3 (GROUND), U68.3 (GROUND), U69.3 (GROUND), U70.1 (ADDRESS_0), U70.2 (ADDRESS_1), U70.8 (GROUND), U71.2 (ADDRESS_1), U71.8 (GROUND), U72.1 (ADDRESS_0), U72.8 (GROUND), U73.8 (GROUND), U74.8 (GROUND); also elsewhere on the board
I2C_SCL: U70.14 (I2C_CLOCK), U71.14 (I2C_CLOCK), U72.14 (I2C_CLOCK), U73.14 (I2C_CLOCK); also elsewhere on the board
I2C_SDA: U70.15 (I2C_DATA), U71.15 (I2C_DATA), U72.15 (I2C_DATA), U73.15 (I2C_DATA); also elsewhere on the board
LED_5V: U7.4 (FIVE_VOLTS), U64.4 (FIVE_VOLTS), U65.4 (FIVE_VOLTS), U66.4 (FIVE_VOLTS), U67.4 (FIVE_VOLTS), U68.4 (FIVE_VOLTS), U69.4 (FIVE_VOLTS); also elsewhere on the board
LED_CLOCK_A1_TO_B1: U7.2 (CLOCK_IN); also elsewhere on the board
LED_CLOCK_B1_TO_C1: U7.5 (CLOCK_OUT); also elsewhere on the board
LED_CLOCK_B8_TO_A8: U68.5 (CLOCK_OUT), U69.2 (CLOCK_IN)
LED_CLOCK_C8_TO_B8: U67.5 (CLOCK_OUT), U68.2 (CLOCK_IN)
LED_CLOCK_D8_TO_C8: U66.5 (CLOCK_OUT), U67.2 (CLOCK_IN)
LED_CLOCK_E8_TO_D8: U65.5 (CLOCK_OUT), U66.2 (CLOCK_IN)
LED_CLOCK_F8_TO_E8: U64.5 (CLOCK_OUT), U65.2 (CLOCK_IN)
LED_CLOCK_G8_TO_F8: U64.2 (CLOCK_IN); also elsewhere on the board
LED_DATA_A1_TO_B1: U7.1 (DATA_IN); also elsewhere on the board
LED_DATA_B1_TO_C1: U7.6 (DATA_OUT); also elsewhere on the board
LED_DATA_B8_TO_A8: U68.6 (DATA_OUT), U69.1 (DATA_IN)
LED_DATA_C8_TO_B8: U67.6 (DATA_OUT), U68.1 (DATA_IN)
LED_DATA_D8_TO_C8: U66.6 (DATA_OUT), U67.1 (DATA_IN)
LED_DATA_E8_TO_D8: U65.6 (DATA_OUT), U66.1 (DATA_IN)
LED_DATA_F8_TO_E8: U64.6 (DATA_OUT), U65.1 (DATA_IN)
LED_DATA_G8_TO_F8: U64.1 (DATA_IN); also elsewhere on the board
SQ_A5: U70.4 (P0); also elsewhere on the board
SQ_A6: U70.6 (P2); also elsewhere on the board
SQ_A7: U72.4 (P0); also elsewhere on the board
SQ_A8: U72.6 (P2); also elsewhere on the board
SQ_B5: U70.5 (P1); also elsewhere on the board
SQ_B6: U70.7 (P3); also elsewhere on the board
SQ_B7: U72.5 (P1); also elsewhere on the board
SQ_B8: U72.7 (P3); also elsewhere on the board
SQ_C5: U70.9 (P4); also elsewhere on the board
SQ_C6: U70.11 (P6); also elsewhere on the board
SQ_C7: U72.9 (P4); also elsewhere on the board
SQ_C8: U72.11 (P6); also elsewhere on the board
SQ_D5: U70.10 (P5); also elsewhere on the board
SQ_D6: U70.12 (P7); also elsewhere on the board
SQ_D7: U72.10 (P5); also elsewhere on the board
SQ_D8: U72.12 (P7); also elsewhere on the board
SQ_E5: U71.4 (P0); also elsewhere on the board
SQ_E6: U71.6 (P2); also elsewhere on the board
SQ_E7: U73.4 (P0); also elsewhere on the board
SQ_E8: U73.6 (P2); also elsewhere on the board
SQ_F5: U71.5 (P1); also elsewhere on the board
SQ_F6: U71.7 (P3); also elsewhere on the board
SQ_F7: U73.5 (P1); also elsewhere on the board
SQ_F8: U73.7 (P3); also elsewhere on the board
SQ_G5: U71.9 (P4); also elsewhere on the board
SQ_G6: U71.11 (P6); also elsewhere on the board
SQ_G7: U73.9 (P4); also elsewhere on the board
SQ_G8: U73.11 (P6); also elsewhere on the board
SQ_H5: U71.10 (P5); also elsewhere on the board
SQ_H6: U71.12 (P7); also elsewhere on the board
SQ_H7: U73.10 (P5); also elsewhere on the board
SQ_H8: U73.12 (P7); also elsewhere on the board

Schematic: components-28.kicad_sch, Components 28: U75 to U9

Parts:
U8, U9: SK9822-A; SK9822
U75: SN74LVC1G97DBVR; LED_ENABLE_GATE

Connections:
+5V: U75.3 (INPUT_0), U75.5 (SUPPLY); also elsewhere on the board
GND: U8.3 (GROUND), U9.3 (GROUND), U75.2 (GROUND); also elsewhere on the board
LED_5V: U8.4 (FIVE_VOLTS), U9.4 (FIVE_VOLTS); also elsewhere on the board
LED_CLOCK_B1_TO_C1: U8.2 (CLOCK_IN); also elsewhere on the board
LED_CLOCK_C1_TO_D1: U8.5 (CLOCK_OUT), U9.2 (CLOCK_IN)
LED_CLOCK_D1_TO_E1: U9.5 (CLOCK_OUT); also elsewhere on the board
LED_DATA_B1_TO_C1: U8.1 (DATA_IN); also elsewhere on the board
LED_DATA_C1_TO_D1: U8.6 (DATA_OUT), U9.1 (DATA_IN)
LED_DATA_D1_TO_E1: U9.6 (DATA_OUT); also elsewhere on the board
LED_EN_N: U75.1 (INPUT_1); also elsewhere on the board
LED_OE_N: U75.4 (OUTPUT); also elsewhere on the board
LED_SW_GATE: U75.6 (INPUT_2); also elsewhere on the board
